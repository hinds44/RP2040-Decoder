# Repository hinds44/RP2040-Decoder

## KiCad design KiCad/v0.3/RP2040-Decoder.kicad_pcb

Parts:
C1, C2, C5, C6, C14: 10u; C_0402_1005Metric
C3, C4, C8, C9, C10, C11, C12, C13, C15: 100n; C_0201_0603Metric
C16, C17: 33p; C_0201_0603Metric
D1: KMB24F; TO-269AA
J1: T0; TestPoint_Pad_D1.5mm
J2: T1; TestPoint_Pad_D1.5mm
J3, J8: 0; TestPoint_Pad_D1.5mm
J4, J9: 1; TestPoint_Pad_D1.5mm
J5, J10: 2; TestPoint_Pad_D1.5mm
J6, J11: 3; TestPoint_Pad_D1.5mm
J7: +3V3; TestPoint_Pad_D1.5mm
J12: 4; TestPoint_Pad_D1.5mm
J13: 5; TestPoint_Pad_D1.5mm
J14: +V; TestPoint_Pad_D1.5mm
J15: M_OUT_B; TestPoint_Pad_D1.5mm
J16: M_OUT_A; TestPoint_Pad_D1.5mm
J17: GND; TestPoint_Pad_D1.5mm
J18: SWCLK; TestPoint_Pad_D1.5mm
J19: SWDIO; TestPoint_Pad_D1.5mm
J20: RUN; TestPoint_Pad_D1.5mm
Q1, Q2, Q3, Q4, Q5: T2N7002BK; SOT-23
R1, R2, R5, R6: 6k8; R_0201_0603Metric
R3: 200; C_0402_1005Metric
R4: DNF; R_0201_0603Metric
R7, R8, R9: 1k; R_0201_0603Metric
U1: PJ75AL33SA; SOT-23
U2: BDR6133; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.41x3.3mm_ThermalVias
U3: W25Q64JVSSIQ; SOIC-8_5.23x5.23mm_P1.27mm
U4: RP2040; QFN-56-1EP_7x7mm_P0.4mm_EP3.2x3.2mm_BigThermalVias
Y1: X322512MSB4SI; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+1V1: C3.1, C4.1, C5.1, U4.23 (DVDD), U4.45 (VREG_VOUT), U4.50 (DVDD)
+3V3: C1.1, C6.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C15.1, J7.1, R3.1, R4.2, U1.2 (VOUT), U2.2 (VCC), U3.8 (VCC), U4.1 (IOVDD), U4.10 (IOVDD), U4.22 (IOVDD), U4.33 (IOVDD), U4.42 (IOVDD), U4.44 (VREG_IN), U4.48 (USB_VDD), U4.49 (IOVDD)
+V: C2.1, D1.3 (+), J14.1, U1.3 (VIN), U2.3 (VM)
/ADC_EMF_A: R5.1, R7.2, U4.40 (GPIO28_ADC2)
/ADC_EMF_B: R6.1, R8.2, U4.41 (GPIO29_ADC3)
/GPIO0: J8.1, U4.2 (GPIO0)
/GPIO1: J9.1, U4.3 (GPIO1)
/GPIO2: J10.1, U4.4 (GPIO2)
/GPIO3: J11.1, U4.5 (GPIO3)
/GPIO4: J12.1, U4.6 (GPIO4)
/GPIO5: J13.1, U4.7 (GPIO5)
/GPIO21: Q1.3 (D), U4.32 (GPIO21)
/GPIO22: U2.7 (INB), U4.34 (GPIO22)
/GPIO23: U2.6 (INA), U4.35 (GPIO23)
/GPIO24: Q2.1 (G), U4.36 (GPIO24)
/GPIO25: Q3.1 (G), U4.37 (GPIO25)
/GPIO26: Q4.1 (G), U4.38 (GPIO26_ADC0)
/GPIO27: Q5.1 (G), U4.39 (GPIO27_ADC1)
/MOTOR_OUT_A: J15.1, R5.2, U2.4 (OUTA)
/MOTOR_OUT_B: J16.1, R6.2, U2.5 (OUTB)
/QSPI_SCLK: U3.6 (CLK), U4.52 (QSPI_SCLK)
/QSPI_SD0: U3.5 (DI(IO0)), U4.53 (QSPI_SD0)
/QSPI_SD1: U3.2 (DO(IO1)), U4.55 (QSPI_SD1)
/QSPI_SD2: U3.3 (IO2), U4.54 (QSPI_SD2)
/QSPI_SD3: U3.7 (IO3), U4.51 (QSPI_SD3)
/QSPI_SS: R4.1, U3.1 (~CS), U4.56 (QSPI_SS)
/RUN: J20.1, U4.26 (RUN)
/SWCLK: J18.1, U4.24 (SWCLK)
/SWDIO: J19.1, U4.25 (SWD)
/XIN: C16.1, U4.20 (XIN), Y1.3
/XOUT: R9.1, U4.21 (XOUT)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, D1.4 (-), J17.1, Q1.2 (S), Q2.2 (S), Q3.2 (S), Q4.2 (S), Q5.2 (S), R2.1, R7.1, R8.1, U1.1 (GND), U2.1 (GND), U2.9 (GND), U3.4 (GND), U4.19 (TESTEN), U4.57 (GND), Y1.2, Y1.4
unnamed: C17.1, R9.2, Y1.1
unnamed: D1.1, J1.1, R1.2
unnamed: D1.2, J2.1
unnamed: J3.1, Q2.3 (D)
unnamed: J4.1, Q3.3 (D)
unnamed: J5.1, Q4.3 (D)
unnamed: J6.1, Q5.3 (D)
unnamed: Q1.1 (G), R1.1, R2.2
unnamed: C14.1, R3.2, U4.43 (ADC_AVDD)

Notes on the sheet:
Gates are pulled down using RP2040 pull-down resistors
Motor Driver
GPIO21 is pulled up internally in RP2040
Aux Outputs
Crystal Oscillator
C5/C6 should be close to pin 45/44
Flash Memory
Input Stage

Board: 2 copper layers, 22.8 x 22.4 mm, 56 parts (21 on the bottom side), 41 nets.

File KiCad/v0.1/production/bom.csv:

Designator,Footprint,Quantity,Value,,Total,5
"C1, C14, C2 ,C5, C6",603,5,10u,,25,
"C10, C11, C12, C13, C15, C3, C4, C7, C8, C9",603,10,100n,,50,
"C16, C17",603,2,33p,,10,
D1,TO-269AA,1,KMB24F,,5,
"Q1, Q2, Q3, Q4, Q5",SOT-23,5,T2N7002BK,,25,
"R1, R2, R5, R6",603,4,6k8,,20,
R3,603,1,200R,,5,
"R7, R8, R9",603,3,1k,,15,
U1,SOT-23,1,PJ75AL33SA,,5,
U2,SOIC-8_3.9x4.9mm_P1.27mm,1,BDR6133,,5,
U3,SOIC-8_5.23x5.23mm_P1.27mm,1,W25Q64JVSSIQ,,5,
U4,QFN-56-1EP_7x7mm_P0.4mm,1,RP2040,,5,
Y1,Crystal_SMD_3225-4Pin_3.2x2.5mm,1,X322512MSB4SI,,5,

## Commit log

2023-03-12 v0.3
